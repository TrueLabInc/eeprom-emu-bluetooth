# Repository TrueLabInc/eeprom-emu-bluetooth

## EAGLE design eagle/eeprom_emu_bt_satland.brd

Parts:
.: MEGA128-A; TQFP64
<-MISO: ICSP; 2X3
ADDRESS_HI_AND_CTRL_BUFFER: 74HCT541DW; SO20W
ADDRESS_LOW_BUFFER: 74HCT541DW; SO20W
C1, C2: 22pF; C0805
C3, C4, C13: 100nF; C0805
C5: 0.33uf; E5-4
C6: 0.1uf; E5-4
D1, D3: MBR0520; SOD-123
DATA_BUFFER: 74HCT541DW; SO20W
EMU_CONN: 27256; DIL28
IC1: REG1117; SOT223
IC2: IS62C256AL-45U; SOP28-330MIL
JP1, JP3: M02LOCK_LONGPADS; 1X02_LOCK_LONGPADS
JP2: M06SILK_FEMALE_PTH; 1X06
LED1, LED2, LED3: LEDSML0805; SML0805
R2, R3, R5: 7k; R0805
R4: 5k; R0805
S4: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
Y2: CRYSTALHC49UV; HC49U-V

Connections:
ADDR_BUFF_OE: ..13 ((MISO)PB3), ADDRESS_HI_AND_CTRL_BUFFER.1 (G1), ADDRESS_HI_AND_CTRL_BUFFER.19 (G2), ADDRESS_LOW_BUFFER.1 (G1), ADDRESS_LOW_BUFFER.19 (G2)
ADDR_CONN0: ADDRESS_LOW_BUFFER.2 (A1), EMU_CONN.10 (A0)
ADDR_CONN1: ADDRESS_LOW_BUFFER.3 (A2), EMU_CONN.9 (A1)
ADDR_CONN2: ADDRESS_LOW_BUFFER.4 (A3), EMU_CONN.8 (A2)
ADDR_CONN3: ADDRESS_LOW_BUFFER.5 (A4), EMU_CONN.7 (A3)
ADDR_CONN4: ADDRESS_LOW_BUFFER.6 (A5), EMU_CONN.6 (A4)
ADDR_CONN5: ADDRESS_LOW_BUFFER.7 (A6), EMU_CONN.5 (A5)
ADDR_CONN6: ADDRESS_LOW_BUFFER.8 (A7), EMU_CONN.4 (A6)
ADDR_CONN7: ADDRESS_LOW_BUFFER.9 (A8), EMU_CONN.3 (A7)
ADDR_CONN8: ADDRESS_HI_AND_CTRL_BUFFER.2 (A1), EMU_CONN.25 (A8)
ADDR_CONN9: ADDRESS_HI_AND_CTRL_BUFFER.3 (A2), EMU_CONN.24 (A9)
ADDR_CONN10: ADDRESS_HI_AND_CTRL_BUFFER.4 (A3), EMU_CONN.21 (A10)
ADDR_CONN11: ADDRESS_HI_AND_CTRL_BUFFER.5 (A4), EMU_CONN.23 (A11)
ADDR_CONN12: ADDRESS_HI_AND_CTRL_BUFFER.6 (A5), EMU_CONN.2 (A12)
ADDR_CONN13: ADDRESS_HI_AND_CTRL_BUFFER.7 (A6), EMU_CONN.26 (A13)
ADDR_CONN14: ADDRESS_HI_AND_CTRL_BUFFER.8 (A7), EMU_CONN.27 (A14)
ADDR_SRAM0: ..51 ((AD0)PA0), ADDRESS_LOW_BUFFER.18 (Y1), IC2.10 (A0)
ADDR_SRAM1: ..50 ((AD1)PA1), ADDRESS_LOW_BUFFER.17 (Y2), IC2.9 (A1)
ADDR_SRAM2: ..49 ((AD2)PA2), ADDRESS_LOW_BUFFER.16 (Y3), IC2.8 (A2)
ADDR_SRAM3: ..48 ((AD3)PA3), ADDRESS_LOW_BUFFER.15 (Y4), IC2.7 (A3)
ADDR_SRAM4: ..47 ((AD4)PA4), ADDRESS_LOW_BUFFER.14 (Y5), IC2.6 (A4)
ADDR_SRAM5: ..46 ((AD5)PA5), ADDRESS_LOW_BUFFER.13 (Y6), IC2.5 (A5)
ADDR_SRAM6: ..45 ((AD6)PA6), ADDRESS_LOW_BUFFER.12 (Y7), IC2.4 (A6)
ADDR_SRAM7: ..44 ((AD7)PA7), ADDRESS_LOW_BUFFER.11 (Y8), IC2.3 (A7)
ADDR_SRAM8: ..35 ((A8)PC0), ADDRESS_HI_AND_CTRL_BUFFER.18 (Y1), IC2.25 (A8)
ADDR_SRAM9: ..36 ((A9)PC1), ADDRESS_HI_AND_CTRL_BUFFER.17 (Y2), IC2.24 (A9)
ADDR_SRAM10: ..37 ((A10)PC2), ADDRESS_HI_AND_CTRL_BUFFER.16 (Y3), IC2.21 (A10)
ADDR_SRAM11: ..38 ((A11)PC3), ADDRESS_HI_AND_CTRL_BUFFER.15 (Y4), IC2.23 (A11)
ADDR_SRAM12: ..39 ((A12)PC4), ADDRESS_HI_AND_CTRL_BUFFER.14 (Y5), IC2.2 (A12)
ADDR_SRAM13: ..40 ((A13)PC5), ADDRESS_HI_AND_CTRL_BUFFER.13 (Y6), IC2.26 (A13)
ADDR_SRAM14: ..41 ((A14)PC6), ADDRESS_HI_AND_CTRL_BUFFER.12 (Y7), IC2.1 (A14)
BT_EN: ..55 (PF6(ADC6/TDO)), JP2.1
BT_STATE: ..54 (PF7(ADC7/TDI)), JP2.6
CE_CONN: DATA_BUFFER.19 (G2), EMU_CONN.20 (!CE); also elsewhere on the board
CE_CONN_CTRL: ..12 ((MOSI)PB2); also elsewhere on the board
DATA_CONN0: DATA_BUFFER.18 (Y1), EMU_CONN.11 (O0)
DATA_CONN1: DATA_BUFFER.17 (Y2), EMU_CONN.12 (O1)
DATA_CONN2: DATA_BUFFER.16 (Y3), EMU_CONN.13 (O2)
DATA_CONN3: DATA_BUFFER.15 (Y4), EMU_CONN.15 (O3)
DATA_CONN4: DATA_BUFFER.14 (Y5), EMU_CONN.16 (O4)
DATA_CONN5: DATA_BUFFER.13 (Y6), EMU_CONN.17 (O5)
DATA_CONN6: DATA_BUFFER.12 (Y7), EMU_CONN.18 (O6)
DATA_CONN7: DATA_BUFFER.11 (Y8), EMU_CONN.19 (O7)
DATA_SRAM0: DATA_BUFFER.2 (A1), IC2.11 (I/O0)
DATA_SRAM1: DATA_BUFFER.3 (A2), IC2.12 (I/O1)
DATA_SRAM2: DATA_BUFFER.4 (A3), IC2.13 (I/O2)
DATA_SRAM3: DATA_BUFFER.5 (A4), IC2.15 (I/O3)
DATA_SRAM4: DATA_BUFFER.6 (A5), IC2.16 (I/O4)
DATA_SRAM5: DATA_BUFFER.7 (A6), IC2.17 (I/O5)
DATA_SRAM6: DATA_BUFFER.8 (A7), IC2.18 (I/O6)
DATA_SRAM7: DATA_BUFFER.9 (A8), IC2.19 (I/O7)
GND: ..22 (GND), ..53 (GND1), ..63 (AGND), <-MISO.6, ADDRESS_HI_AND_CTRL_BUFFER.10 (GND), ADDRESS_LOW_BUFFER.10 (GND), C1.1, C2.1, C3.2, C4.2, C5.-, C6.-, C13.2, DATA_BUFFER.10 (GND), EMU_CONN.14 (GND), IC1.1 (GND), IC2.14 (GND), JP2.3, JP3.2, LED1.C, LED2.C, LED3.C, S4.2
MISO: ..3 ((TXD/PDO)PE1), <-MISO.1, JP2.5
MOSI: ..2 ((RXD/PDI)PE0), <-MISO.4, JP2.4
unnamed: ..24 (XTAL1), C2.2, Y2.1
unnamed: ..23 (XTAL2), C1.2, Y2.2
unnamed: C5.+, D1.1 (CA), IC1.3 (VIN), JP3.1
unnamed: D3.1 (CA), EMU_CONN.28 (VCC)
unnamed: ..28 ((TXD1/INT3)PD3), JP1.1
unnamed: ..32 ((T2)PD7), R2.1
unnamed: LED1.A, R2.2
unnamed: ..31 ((T1)PD6), R3.1
unnamed: LED2.A, R3.2
unnamed: ..30 ((XCK1)PD5), R5.1
unnamed: LED3.A, R5.2
unnamed: ..27 ((RXD1/INT2)PD2), JP1.2
OE_CONN: ADDRESS_HI_AND_CTRL_BUFFER.9 (A8), DATA_BUFFER.1 (G1), EMU_CONN.22 (!OE)
RESET: ..20 (RESET), <-MISO.5, R4.1, S4.1
SCK: ..11 ((SCK)PB1), <-MISO.3
SRAM_CE: ..17 ((OC2/OC1C)PB7), IC2.20 (!CE); also elsewhere on the board
SRAM_OE: ..16 ((OC1B)PB6), ADDRESS_HI_AND_CTRL_BUFFER.11 (Y8), IC2.22 (!OE)
SRAM_WE: ..15 ((OC1A)PB5), IC2.27 (!WE)
VCC: ..21 (VCC), ..52 (VCC1), ..64 (AVCC), <-MISO.2, ADDRESS_HI_AND_CTRL_BUFFER.20 (VCC), ADDRESS_LOW_BUFFER.20 (VCC), C3.1, C4.1, C6.+, C13.1, D1.2 (AN), D3.2 (AN), DATA_BUFFER.20 (VCC), IC1.2 (VOUT), IC2.28 (VDD), JP2.2, R4.2; also elsewhere on the board

Board: 2 copper layers, 67.2 x 50.1 mm, 34 parts (8 on the bottom side), 77 nets.

Other parts of the board:
AND_G:Q1, AND_G:Q4: BC817-16LT1SMD; SOT23-BEC
AND_G:R1, AND_G:R5: 7k; R0805
AND_G:R7: 500; R0805

Their connections:
AND_G:N$3: AND_G:Q1.C, AND_G:Q4.E
AND_G:N$4: AND_G:Q1.B, AND_G:R1.1
AND_G:N$5: AND_G:Q4.C, AND_G:R7.2
AND_G:N$31: AND_G:Q4.B, AND_G:R5.1
CE_CONN: AND_G:R1.2; also elsewhere on the board
CE_CONN_CTRL: AND_G:R5.2; also elsewhere on the board
SRAM_CE: AND_G:Q1.E; also elsewhere on the board
VCC: AND_G:R7.1; also elsewhere on the board

## EAGLE design eagle/eeprom_emu_bt.brd

Parts:
.: MEGA128-A; TQFP64
<-MISO: ICSP; 2X3
BLUETOOTH: M05PTH; 1X05
C1, C2: 22pF; C0805
C3, C4, C13: 100nF; C0805
IC1: 27256; DIL28
IC2: IS62C256AL-45U; SOP28-330MIL
IC3, IC4, IC5, IC6, IC7, IC8: 74HCT541DW; SO20W
IC9: 74HC573D; SO20W
R4: 5k; R0805
U1: SST39SF040-70-4I-NHE; PLCC127P1244X1498X357-32N
Y1: CRYSTALHC49US; HC49US

Connections:
A8: ..35 ((A8)PC0)
A9: ..36 ((A9)PC1)
A10: ..37 ((A10)PC2)
A11: ..38 ((A11)PC3)
A12: ..39 ((A12)PC4)
A13: ..40 ((A13)PC5)
A14: ..41 ((A14)PC6)
GND: ..22 (GND), ..53 (GND1), ..63 (AGND), <-MISO.6, C1.1, C2.1, C3.2, C4.2, C13.2, IC1.14 (GND), IC2.14 (GND), IC3.10 (GND), IC4.10 (GND), IC5.10 (GND), IC6.10 (GND), IC7.10 (GND), IC8.10 (GND), IC9.10 (GND)
MISO: ..3 ((TXD/PDO)PE1), <-MISO.1
MOSI: ..2 ((RXD/PDI)PE0), <-MISO.4
unnamed: ..24 (XTAL1), C2.2, Y1.1
unnamed: ..23 (XTAL2), C1.2, Y1.2
RESET: ..20 (RESET), <-MISO.5, R4.1
SCK: ..11 ((SCK)PB1), <-MISO.3
VCC: ..21 (VCC), ..52 (VCC1), ..64 (AVCC), <-MISO.2, C3.1, C4.1, C13.1, IC1.28 (VCC), IC3.20 (VCC), IC4.20 (VCC), IC5.20 (VCC), IC6.20 (VCC), IC7.20 (VCC), IC8.20 (VCC), IC9.20 (VCC), R4.2
VDD: IC2.28 (VDD), U1.32 (VDD)

Board: 2 copper layers, 20 parts (6 on the bottom side), 9 nets, no tracks yet.

## Code that names these connections

File c_source/buffers_ctrl.h:

/*
 * buffers_ctrl.h
 *
 *  Created on: Sep 25, 2016
 *      Author: rafal
 */

#ifndef BUFFERS_CTRL_H_
#define BUFFERS_CTRL_H_

#include <stdlib.h>
#include <avr/io.h>
#include "pins.h"

class BuffersCtrl{
public:
	typedef enum pins{
		addr_buff_oe_pin = PB3,
		ce_conn_ctrl_pin = PB2,
	}pins;
	BuffersCtrl();
	class addr_buff_oe_ {
	public:
		void operator=(pin_state state){
			if(state == pin_state::hi)
				PORTB |= _BV(pins::addr_buff_oe_pin);
			else if(state == pin_state::toggle)
				PORTB ^= _BV(pins::addr_buff_oe_pin);
			else{
				PORTB &= ~_BV(pins::addr_buff_oe_pin);
			}
		}
	};
	class ce_conn_ctrl_ {
	public:
		void operator=(pin_state state){
			if(state){
				PORTB |= _BV(ce_conn_ctrl_pin);
			}
			else{
				PORTB &= ~_BV(ce_conn_ctrl_pin);
			}
		}
	};
	addr_buff_oe_ address_port_conn; ce_conn_ctrl_ ce_conn_ctrl;

};

//class PinModify{
//public:
//	BuffersCtrl::pins _pin;
//	PinModify(BuffersCtrl::pins pin);
//	void operator=(pin_state state){
//		if(state == pin_state::hi)
//			PORTB |= _BV(_pin);
//		else if(state == pin_state::toggle)
//			PORTB ^= _BV(_pin);
//		else{
//			PORTB &= ~_BV(_pin);
//		}
//	}
//};
//
//PinModify::PinModify(BuffersCtrl::pins  pin){
//	_pin = pin;
//}

#endif /* BUFFERS_CTRL_H_ */

## Commit log

2016-07-26 documents folder
2016-07-26 new files
2016-07-26 eagle files
2016-07-26 files moved into eagle directory
2016-07-26 27c256 added
2016-07-26 eagle lib with sstsf39 chips
2016-07-26 ISSI srams lib
2016-07-26 eagles
2016-07-27 test
2016-07-27 test file removed
2016-07-29 or gate added for CE of sram
2016-09-27 how to redefine avr ports
2016-09-29 huffman tree generator
2016-10-05 new docs
2016-10-05 python scripts
2016-10-05 file will be removed
2016-10-05 as I said
2016-10-05 source add test with link
2016-10-05 test fail
2016-10-05 c++ sources added
2016-10-14 huffman working algorithm
2016-11-24 Create tmp.h
    some example solutions
2016-11-30 big update
2016-11-30 remove for update
2016-11-30 fully updated directory
2016-11-30 eagle update
2016-11-30 eagle files removed
2016-12-06 new way
2016-12-08 script will create a sequence of diffs
2016-12-14 example of disabled groubBox with nice title
2016-12-19 example how to discover bt devices
2016-12-20 rework with gui
2017-01-02 example
    How to get text from combobox, read on event, connect event signal
2017-01-02 grid layout
2017-01-02 new update

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
